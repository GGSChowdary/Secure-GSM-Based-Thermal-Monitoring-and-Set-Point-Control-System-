# Keil uVision project GSM.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: major_test +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s delay.c eint0.c i2c.c i2c_eeprom.c keypad.c lcd.c main.c menu.c rtc.c dht11.c UART_INT.c gsm.c defines.h delay.h dht11.h gsm.h i2c.h i2c_defines.h i2c_eeprom_defines.h keypad.h keypad_defines.h lcd.h lcd_defines.h menu.h rtc.h rtc_defines.h types.h uart.h uart_int.h
